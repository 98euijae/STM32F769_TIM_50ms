<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\769TIM_50ms.ewp</path>
  </project>
  <batchBuild />
</workspace>
